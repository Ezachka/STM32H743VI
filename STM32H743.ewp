# IAR project STM32H743.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; CORE_CM7; HSE_VALUE=25000000UL; HSI_VALUE=64000000UL
  ICCARM.CCIncludePath2: STM32H743\Libraries\CMSIS\Core; STM32H743\Libraries\CMSIS; STM32H743\Libraries; STM32H743\Application; STM32H743\Config; STM32H743\Drivers; STM32H743\Services; STM32H743\Services\Display; STM32H743\Utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H743.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group Application
    STM32H743/Application/: main.c
  group Config
    STM32H743/Config/: encoders_config.h gpio_config.h
  group Libraries
    STM32H743/Libraries/: dwt_tim.h peripherals_init.c peripherals_init.h stm32h7xx_gpio.c stm32h7xx_gpio.h stm32h7xx_i2c.c stm32h7xx_i2c.h stm32h7xx_interrupts.c stm32h7xx_interrupts.h stm32h7xx_rcc.c stm32h7xx_rcc.h stm32h7xx_spi.c stm32h7xx_spi.h stm32h7xx_tim.c stm32h7xx_tim.h stm32h7xx_usart.c stm32h7xx_usart.h
  group Libraries/CMSIS
    STM32H743/Libraries/CMSIS/: startup_stm32h743xx.s stm32h743xx.h stm32h7xx.h system_stm32h7xx.c system_stm32h7xx.h
  group Libraries/CMSIS/CORE
    STM32H743/Libraries/CMSIS/Core/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h irq_ctrl.h mpu_armv7.h mpu_armv8.h tz_context.h
  group Services
    STM32H743/Services/: encoder.c encoder.h leds.c leds.h lis3dh.c lis3dh.h softuart.c softuart.h
  group Services/display
    STM32H743/Services/Display/: bitmap.h fonts.c fonts.h SH1106.c SH1106.h
  group Utils
    STM32H743/Utils/: base.c base.h
